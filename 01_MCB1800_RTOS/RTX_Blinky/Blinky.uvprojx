# Keil uVision project Blinky.uvprojx, settings and files
target LPC1857 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Blinky.cpp OOP_Example.cpp OOP_Example.h SingleLinkedList.cpp SingleLinkedList.h
  group Documentation
    ./: Abstract.txt
target LPC1857 RAM (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x10000
target EventRecorder (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.7.0
  cpu: as above
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c misc: --cpp11
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x20005000 size 0x5000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:Event Recorder 1.1.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:LED 1.0.0, Device:GPIO 1.0.0, Device:SCU 1.1.0, Device:Startup 1.0.0
